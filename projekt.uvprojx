# Keil uVision project projekt.uvprojx, settings and files
target default (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: projekt
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DATA_IN_ExtSDRAM,STM32F429I_DISCOVERY,HSE_VALUE=8000000
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group application
    ./application/: main.c
software components: CMSIS:CORE 5.0.0, CMSIS:RTOS:Keil RTX5 5.0.0-Alpha, CMSIS:RTOS2:Keil RTX5 5.0.0-Alpha, Board Support:emWin LCD 1.0.0, CMSIS Driver:SPI 2.8, Device:STM32Cube Framework:Classic 1.5.0, Device:STM32Cube HAL:Common 1.5.0, Device:STM32Cube HAL:Cortex 1.5.0, Device:STM32Cube HAL:DMA 1.5.0, Device:STM32Cube HAL:DMA2D 1.5.0, Device:STM32Cube HAL:GPIO 1.5.0, Device:STM32Cube HAL:LTDC 1.5.0, Device:STM32Cube HAL:PWR 1.5.0, Device:STM32Cube HAL:RCC 1.5.0, Device:STM32Cube HAL:SPI 1.5.0, Device:Startup 2.5.0, Graphics Display:STM32F429I-Discovery 1.0.0, Graphics:CORE 5.32.2
